options:
  parameters:
    generate_options: qt_gui
    id: QuickTest
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 433.8e6
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: 433.8e6
    fftsize: '1024'
    type: complex
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 10e6
    center_freq: 433.8e6
    dev_args: driver=lime,antenna=LNAH
    gain: '40.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
